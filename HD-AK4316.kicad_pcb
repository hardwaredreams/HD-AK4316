# Repository hardwaredreams/HD-AK4316

## KiCad design HD-AK4316.kicad_pcb

Parts:
C1: 1u; generic-c1608
C2: 470p; generic-c1608
C3: 2.2u; generic-c1608
C4: 1u; generic-thru-c
C5: 2.2u; generic-thru-c
CN1, CN2: HY-2-THRU; grove-HY-2-THRU
R1, R2, R3: 10k; generic-R1608-thru
R4: OPEN; generic-R1608-thru
R5: 0; generic-R1608-thru
R6: 887k; generic-R1608-thru
R7: 1000k; generic-R1608-thru
U1: AE-LTC4316
U2: MIC5219-3.3YM5; generic-SOT23-5
U3: LP2950L-33-T92-K; GENERIC-TO-92

Connections:
+3V3: C3.1, C5.1, R1.1, R2.1, R3.1, R4.1, R6.1, U1.1 (VCC), U1.2 (EN), U2.5 (VOUT), U3.1 (OUT)
+5V: C1.1, C4.1, CN1.3, CN2.3, U2.1 (VIN), U2.3 (EN), U3.3 (IN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, CN1.4, CN2.4, R5.2, R7.2, U1.10 (GND), U2.2 (GND), U3.2 (GND)
unnamed: R1.2, U1.3 (READY)
unnamed: CN1.1, U1.4 (SCLIN)
unnamed: CN2.1, R2.2, U1.7 (SCLOUT)
unnamed: CN1.2, U1.5 (SDAIN)
unnamed: CN2.2, R3.2, U1.6 (SDAOUT)
unnamed: R4.2, R5.1, U1.9 (XORH)
unnamed: R6.2, R7.1, U1.8 (XORL)
unnamed: C2.1, U2.4 (BYP)

Notes on the sheet:
RHB
※ 3.3V 電源ブロック - スルーホール版
RLT
RHT
※ 3.3V 電源ブロックは、 SMT版 または スルーホール版の いずれか、一方のみを実装する
※ 3.3V 電源ブロック - SMT版
RLB

Board: 2 copper layers, 70.0 x 25.0 mm, 17 parts (0 on the bottom side), 11 nets.

## Commit log

2024-04-13 1st commit
2024-04-13 add gerber.zip file
2024-04-13 remove old files
2024-04-13 remove old version
2024-04-17 add files, gerber and drill
2024-04-17 add files, kicad files and bomlist
2024-04-24 update: U2: partsnumber
2024-04-24 update anchor for build page
2024-04-24 remove zip file
